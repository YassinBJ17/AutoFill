Data.dump (0x500++0x5F) /DIALOG