Data.dump (0x10000000++0x7F) /DIALOG