Data.dump (0x8E30++0x3) /DIALOG