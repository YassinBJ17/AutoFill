Data.dump (0x7FFFC++0x3) /DIALOG